# Keil uVision project app.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe --bincombined ".\Obj\@L.axf" --output "..\output\bin\@L.bin"
  AfterMake: cmd.exe /C copy /Y .\Obj\@L.hex ..\output\hex\@L.hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\tftlcd;.\APP\flash;.\APP\spi;.\APP\stm32_flash;.\APP\touch;.\Malloc;.\APP\sd_sdio;.\Fatfs\src;.\Fatfs\fatfs_app;.\APP\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x3d000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/spi/: spi.c
    ./APP/flash/: flash.c
    ./APP/sd_sdio/: sd_sdio.c
    ./APP/oled/: oled.c
    ./APP/pwm/: pwm.c
    ./APP/time/: time.c
    ./APP/stm32_flash/: stm32_flash.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Malloc
    ./Malloc/: malloc.c
  group Fatfs
    ./Fatfs/src/: diskio.c ff.c
    ./Fatfs/fatfs_app/: fatfs_app.c
    ./Fatfs/src/option/: cc936.c
