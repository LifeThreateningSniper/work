# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: cmd.exe /C copy /Y .\Objects\@L.hex ..\..\output\目标机\@L.hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103xE USE_FULL_ASSERT USE_HAL_DRIVER
  c include: .\STM32F1xx_HAL_Driver;.\STM32F1xx_HAL_Driver\Inc;.\oled
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c common.c
    ./oled/: oled.c
  group STM32F1xx_HAL_Driver
    ./STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    ./STM32F1xx_HAL_Driver/: system_stm32f1xx.c startup_stm32f103xe.s
